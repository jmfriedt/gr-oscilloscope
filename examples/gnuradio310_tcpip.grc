options:
  parameters:
    author: jmfriedt
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: gnuradio310_tcpip
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_vector_to_stream_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: N
    type: float
  states: {}
- name: oscilloscope_oscilloscope_0
  id: oscilloscope_oscilloscope
  parameters:
    channels: '3'
    comment: |-
      RTO2034: 192.168.1.201
      TCP/IP:     127.0.0.1:9999
      DSOS404A: 192.168.200.11
    duration: N
    ip: 127.0.0.1
    range: '.5'
    rate: '1'
    type: '0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '3'
    size: N
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_to_stream_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_vector_to_stream_0_1, '0', qtgui_time_sink_x_0, '1']
- [oscilloscope_oscilloscope_0, '0', blocks_vector_to_stream_0, '0']
- [oscilloscope_oscilloscope_0, '1', blocks_vector_to_stream_0_1, '0']
- [oscilloscope_oscilloscope_0, '2', blocks_vector_to_stream_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
