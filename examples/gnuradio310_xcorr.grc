options:
  parameters:
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: gnuradio310_xcorr
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: int(samp_rate*duration)
  states: {}
- name: duration
  id: variable
  parameters:
    value: '1e-6'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e9
  states: {}
- name: samples
  id: variable
  parameters:
    value: duration*samp_rate
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: N
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: N
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: N
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: N
    type: complex
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: int(duration*samp_rate)
    type: float
  states: {}
- name: blocks_vector_to_stream_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: int(duration*samp_rate)
    type: float
  states: {}
- name: blocks_vector_to_stream_1_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: int(duration*samp_rate)
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, vlen=5000):  # args show up as parameters in GRC
              gr.sync_block.__init__(self, name='xcorr interp',   # name in GRC
                  in_sig=[(np.complex64,vlen)], out_sig=[])
          def work(self, input_items, output_items):
              for k in range(0,len(input_items)) :
                  v=np.abs(input_items[0][k])
                  n=np.argmax(v)
                  ynm1=v[n-1]
                  ynp1=v[n+1]
                  yn=v[n]
                  dy=1/2*(ynp1-ynm1)/(2*yn-ynp1-ynm1)
                  print(f"2 {n+dy:.3f}")
              return len(input_items[0])
    comment: |-
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, vlen=5000):  # args = parameters in GRC
              gr.sync_block.__init__(self, name='xcorr interp',   # name in GRC
                  in_sig=[(np.complex64,vlen)], out_sig=[])
          def work(self, input_items, output_items):
              for k in range(0,len(input_items)) :
                  v=np.abs(input_items[0][k])
                  n=np.argmax(v)
                  ynm1=v[n-1]
                  ynp1=v[n+1]
                  yn=v[n]
                  dy=1/2*(ynp1-ynm1)/(2*yn-ynp1-ynm1)
                  print(f"2 {n+dy:.3f}")
              return len(input_items[0])
    vlen: '5000'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, vlen=5000):  # args show up as parameters in GRC
              gr.sync_block.__init__(self, name='xcorr interp',   # name in GRC
                  in_sig=[(np.complex64,vlen)], out_sig=[])
          def work(self, input_items, output_items):
              for k in range(0,len(input_items)) :
                  v=np.abs(input_items[0][k])
                  n=np.argmax(v)
                  ynm1=v[n-1]
                  ynp1=v[n+1]
                  yn=v[n]
                  dy=1/2*(ynp1-ynm1)/(2*yn-ynp1-ynm1)
                  print(f"1 {n+dy:.3f}")
              return len(input_items[0])
    vlen: '5000'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'False'
    shift: 'True'
    type: float
    window: window.blackmanharris(N)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'False'
    shift: 'True'
    type: float
    window: window.blackmanharris(N)
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'False'
    shift: 'True'
    type: float
    window: window.blackmanharris(N)
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(N)
  states: {}
- name: fft_vxx_1_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(N)
  states: {}
- name: oscilloscope_oscilloscope_0
  id: oscilloscope_oscilloscope
  parameters:
    channels: '3'
    comment: |-
      RTO2034 192.168.1.201
      DSOS404A 192.168.200.11
      DHO814 192.168.40.4
    duration: duration
    ip: 192.168.1.201
    range: '1.5'
    rate: samp_rate
    type: '2'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    nconnections: '3'
    size: int(samp_rate*duration)
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: N
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: N
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_mag_0_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', fft_vxx_1, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', fft_vxx_1_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_complex_to_mag_0_0, '0']
- [blocks_vector_to_stream_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_to_stream_1_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_vector_to_stream_1_0_0, '0', qtgui_time_sink_x_0, '2']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_0_1, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [fft_vxx_1, '0', blocks_vector_to_stream_0, '0']
- [fft_vxx_1, '0', epy_block_0_0, '0']
- [fft_vxx_1_0, '0', blocks_vector_to_stream_0_0, '0']
- [fft_vxx_1_0, '0', epy_block_0, '0']
- [oscilloscope_oscilloscope_0, '0', blocks_vector_to_stream_1, '0']
- [oscilloscope_oscilloscope_0, '0', fft_vxx_0, '0']
- [oscilloscope_oscilloscope_0, '1', blocks_vector_to_stream_1_0, '0']
- [oscilloscope_oscilloscope_0, '1', fft_vxx_0_0, '0']
- [oscilloscope_oscilloscope_0, '2', blocks_vector_to_stream_1_0_0, '0']
- [oscilloscope_oscilloscope_0, '2', fft_vxx_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
