options:
  parameters:
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: gnuradio310_xcorr
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: '2048'
  states: {state: disabled}
- name: duration
  id: variable
  parameters:
    value: '1e-6'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e9
  states: {}
- name: samples
  id: variable
  parameters:
    value: duration*samp_rate
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: N
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: N
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {state: disabled}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {state: disabled}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: N
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: N
    type: complex
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'False'
    shift: 'True'
    type: float
    window: window.blackmanharris(N)
  states: {state: disabled}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'False'
    shift: 'True'
    type: float
    window: window.blackmanharris(N)
  states: {state: disabled}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'False'
    shift: 'True'
    type: float
    window: window.blackmanharris(N)
  states: {state: disabled}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(N)
  states: {state: disabled}
- name: fft_vxx_1_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(N)
  states: {state: disabled}
- name: oscilloscope_oscilloscope_0
  id: oscilloscope_oscilloscope
  parameters:
    channels: '3'
    comment: |-
      RTO2034 192.168.1.201
      DSOS404A 192.168.200.11
    duration: duration
    ip: 192.168.200.11
    range: '1.5'
    rate: samp_rate
    type: '1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    nconnections: '3'
    size: int(samp_rate*duration)
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: N
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    size: N
    srate: samp_rate
    type: float
  states: {state: disabled}

connections:
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_mag_0_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', fft_vxx_1, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', fft_vxx_1_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_0_1, '0', fft_vxx_0_1, '0']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_complex_to_mag_0_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_0_1, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [fft_vxx_1, '0', blocks_vector_to_stream_0, '0']
- [fft_vxx_1_0, '0', blocks_vector_to_stream_0_0, '0']
- [oscilloscope_oscilloscope_0, '0', blocks_stream_to_vector_0, '0']
- [oscilloscope_oscilloscope_0, '0', qtgui_time_sink_x_0, '0']
- [oscilloscope_oscilloscope_0, '1', blocks_stream_to_vector_0_0, '0']
- [oscilloscope_oscilloscope_0, '1', qtgui_time_sink_x_0, '1']
- [oscilloscope_oscilloscope_0, '2', blocks_stream_to_vector_0_1, '0']
- [oscilloscope_oscilloscope_0, '2', qtgui_time_sink_x_0, '2']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
