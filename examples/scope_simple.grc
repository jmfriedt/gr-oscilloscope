options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: duration
  id: variable
  parameters:
    value: '1e-6'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e9
  states: {}
- name: samples
  id: variable
  parameters:
    value: int(duration*samp_rate)
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: oscilloscope_oscilloscope_0
  id: oscilloscope_oscilloscope
  parameters:
    channels: '4'
    comment: 'RTE1054: 192.168.1.43'
    duration: duration
    ip: 127.0.0.1
    range: '.2'
    rate: samp_rate
    type: '0'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    label3: ''
    label4: ''
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [oscilloscope_oscilloscope_0, '0', qtgui_time_sink_x_1, '0']
- [oscilloscope_oscilloscope_0, '1', qtgui_time_sink_x_1, '1']
- [oscilloscope_oscilloscope_0, '2', qtgui_time_sink_x_1, '2']
- [oscilloscope_oscilloscope_0, '3', blocks_throttle2_0, '0']
- [oscilloscope_oscilloscope_0, '3', qtgui_time_sink_x_1, '3']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
